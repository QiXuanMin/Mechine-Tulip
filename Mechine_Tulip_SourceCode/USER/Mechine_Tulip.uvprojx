# Keil uVision project Mechine_Tulip.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PAJ7620U2 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_HAL_DRIVER,USE_HAL_LEGACY,STM32F103xB
  c misc: --C99
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\PAJ7620U2;..\HARDWARE\LCD12864;..\HARDWARE\RELAY;..\HARDWARE\WS2812B;..\HARDWARE\PWM
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c servo.c servo.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f103xb.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/PAJ7620U2/: paj7620u2.c paj7620u2_iic.c
    ../HARDWARE/LCD12864/: LCD12864.c LCD12864.h bmplib.c bmplib.h
    ../HARDWARE/RELAY/: relay.c relay.h
    ../HARDWARE/WS2812B/: ws2812b.c ws2812b.h
    ../HARDWARE/PWM/: pwm.c pwm.h
  group README
    ../: README.TXT
